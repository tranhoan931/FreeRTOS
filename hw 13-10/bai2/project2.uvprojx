# Keil uVision project project2.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\Keil_v5\FreeRTOS-LTS\FreeRTOS\FreeRTOS-Kernel\include;C:\Keil_v5\FreeRTOS-LTS\FreeRTOS\FreeRTOS-Kernel\portable\RVDS\ARM_CM3
  asm include: C:\Keil_v5\FreeRTOS-LTS\FreeRTOS\FreeRTOS-Kernel\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: main.c
  group FreeRTOS
    C:/Keil_v5/FreeRTOS-LTS/FreeRTOS/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    C:/Keil_v5/FreeRTOS-LTS/FreeRTOS/FreeRTOS-Kernel/portable/RVDS/ARM_CM3/: port.c
    C:/Keil_v5/FreeRTOS-LTS/FreeRTOS/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.3.0, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
